DEFAULT_PREFERENCE_raspberrypi2 = "0"

SRCREV_raspberrypi2 = "97be70b45eccc37e98a1cecf360593f36956ea42"
PV_raspberrypi2 = "2.4.61+git${SRCPV}"
