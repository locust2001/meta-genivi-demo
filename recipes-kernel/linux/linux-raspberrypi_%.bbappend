CMDLINE += "cma=256M"
